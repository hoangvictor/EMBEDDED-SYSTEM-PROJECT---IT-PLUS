# IAR project Backup of IAR_TEST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\MKL46Z; ..\source; E:\LAST_PROJECT_IAR\drivers\display; ..\drivers\gpio; ..\drivers\keypad; ..\drivers\lcd; ..\drivers\rtc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_TEST.srec
  ILINK.IlinkOutputFile: IAR_TEST.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drivers/display
    ../drivers/display/: display.c display.h
  group drivers/gpio
    ../drivers/gpio/: GPIO.c GPIO.h
  group drivers/keypad
    ../drivers/keypad/: Key_Pad.c Key_Pad.h
  group drivers/lcd
    ../drivers/lcd/: LCD.c LCD.h
  group drivers/rtc
    ../drivers/rtc/: RTC_KL46.c RTC_KL46.h
  group source
    ../source/: main.c
  group startup
    ../MKL46Z/: startup_MKL46Z4.s system_MKL46Z4.c system_MKL46Z4.h
